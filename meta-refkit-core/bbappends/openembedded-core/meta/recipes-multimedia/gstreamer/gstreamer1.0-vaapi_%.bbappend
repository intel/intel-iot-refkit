PACKAGECONFIG_remove_df-refkit-config = "glx"
EXTRA_OECONF_append_df-refkit-config = " --disable-egl"
