DEPENDS_remove_df-refkit-config = "gconf"
EXTRA_OECONF_append_df-refkit-config = " --disable-gconf"
