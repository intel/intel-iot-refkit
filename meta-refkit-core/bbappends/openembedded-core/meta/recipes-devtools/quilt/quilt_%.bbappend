EXTRA_OECONF_append_df-refkit-config = " \
    --without-sendmail \
    --with-awk=/usr/bin/awk \
"
