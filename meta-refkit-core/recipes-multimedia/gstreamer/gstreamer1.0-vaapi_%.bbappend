PACKAGECONFIG_remove_refkit-config = "glx"
EXTRA_OECONF_append_refkit-config = " --disable-egl"
