DEPENDS_remove = "gconf"
EXTRA_OECONF += "--disable-gconf"
