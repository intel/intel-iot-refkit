SUMMARY = "Components for common profile testing and interactive use"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = " \
    connman-client \
"
