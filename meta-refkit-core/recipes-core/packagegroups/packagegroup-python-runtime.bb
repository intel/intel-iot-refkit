SUMMARY = "Runtime for Python Apps"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = " \
    python3-modules \
"
