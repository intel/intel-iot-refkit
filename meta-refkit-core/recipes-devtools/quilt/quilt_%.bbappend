EXTRA_OECONF += " \
    --without-sendmail \
    --with-awk=/usr/bin/awk \
"
