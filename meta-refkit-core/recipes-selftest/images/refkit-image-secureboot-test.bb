SUMMARY = "test image for SecureBootTests"

require ${META_REFKIT_CORE_BASE}/recipes-images/images/refkit-image-common.bb
