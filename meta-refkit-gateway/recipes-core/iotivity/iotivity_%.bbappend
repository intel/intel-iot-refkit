FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_df-refkit-gateway = " \
    file://0001-resource-Include-functional-header-for-g-7.1.0.patch \
"
