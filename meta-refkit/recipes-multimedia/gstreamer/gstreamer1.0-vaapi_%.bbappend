PACKAGECONFIG_remove = "glx"
EXTRA_OECONF += " --disable-egl"
