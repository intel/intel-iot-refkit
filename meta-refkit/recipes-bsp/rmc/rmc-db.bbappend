RMC_BOARD_DATA_DIRS_append := " ${THISDIR}/rmc"
