#FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

#SRC_URI_append = " file://0001-drm-i915-Fix-i915_gem_evict_for_vma-soft-pinning.patch"
KBRANCH = "experimental/base-new-drm"
SRCREV_machine = "6f425e57c6afaed5d61cd9b8abe898bae97f9374"
LINUX_VERSION = "4.9.15"
