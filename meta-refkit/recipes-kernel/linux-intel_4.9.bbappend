FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0001-drm-i915-Fix-i915_gem_evict_for_vma-soft-pinning.patch"
