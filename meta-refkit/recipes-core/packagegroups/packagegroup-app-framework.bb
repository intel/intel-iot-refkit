SUMMARY = "IoT Reference OS Kit Application Framework"
LICENSE = "MIT"

inherit packagegroup

RDEPENDS_${PN} = " \
    iot-app-fw \
"
