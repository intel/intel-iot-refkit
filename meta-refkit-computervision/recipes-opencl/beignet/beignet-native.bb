# Recipe for compiling beignet-native
inherit native

require beignet.inc
