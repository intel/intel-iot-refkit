DEPENDS += "snappy"
